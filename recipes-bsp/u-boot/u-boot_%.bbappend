require u-boot-sp7021.inc