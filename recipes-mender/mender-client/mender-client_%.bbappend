
RDEPENDS:${PN} += "ca-certificates"
