
IMAGE_FSTYPES:append = " dataimg"
